## esp32/firmware/sdkconfig.defaults
```kconfig
CONFIG_IDF_TARGET="esp32"
CONFIG_ESP_DEFAULT_CPU_FREQ_MHZ_240=y
CONFIG_DAC_SUPPRESS_DEPRECATE_WARN=y
CONFIG_ESP_TASK_WDT_CHECK_IDLE_TASK_CPU1=n
```
